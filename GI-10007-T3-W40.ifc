Properties of the parts of a building model (IFC2X3)

# File
Time: 2019-01-09T12:20:09
Written by: Xbim File Processor version 4.0.0.0
Made in: Xbim version 4.0.0.0

# IfcDistributionPort (4)
Name | FlowDirection
2 x  | SOURCE
2 x  | SINK

# IfcFlowTerminal: GI-10007-T3-W40 (2)
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT

# IfcFlowTerminal: Gino Bollards LED
In: Default Building
Type - Description: Wall mounted luminaires with upward and downward light distributions. Ideally suited to illuminate wall and surfaces, all possible to create light accents on vertical surfaces using LED lamp. The luminaire rated as CLASS I with integral driver. Colour temperature 2700K, 3000K and 4000K, LED CRI >80 and life time 50,000 Hours. Low copper content corrosion resistant die-cast aluminum frame and body. Stainless steel screws. Durable silicone rubber gasket and impact resistant toughened glass diffuser The luminaire is treated with a chemical chromatized protection before powder coating, ensuring high corrosion resistance. Lamp: 2X8 LED LED colour: 4000 K Power: 19 w. Weight: 10.0 kg. IP65 /EN 60598/CLASS I / CE /IK04; PredefinedType: DIRECTIONSOURCE
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: Gino, Bollard-Garden light-Pilar light; Housing color: All
General Information - Weight: 10 kg; Case length: 30 cm; Case width: 30.4 cm; Case height: 100 cm; Article name: Gino Bollards LED; Uld creation date: 01.09.2019 00:00:00
Photometric Information - Light output ratio: 0.999594; Luminous flux: 828.331 lm; Lamp names: GI-10007-T3-W40; sets with these values: 2
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 10.2 W
Pset_LightFixtureTypeCommon - NumberOfSources: 2; TotalWattage: 10.2 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
Pset_LampTypeCommon - ContributedLuminousFlux: 828.331 lm; LightEmitterNominalPower: 10.2 W; Spectrum: 380: 0.012934, 385: 0.01155, 390: 0.011614, 395: 0.010494, 400: 0.010484, 405: 0.010279, 410: 0.00968, 415: 0.011352, 420: 0.017493, 425: 0.049381, 430: 0.110001, 435: 0.213323, 440: 0.422394, 445: 0.673726, 450: 0.939462, 455: 0.97829, 460: 0.851938, 465: 0.670014, 470: 0.549521, 475: 0.442322, 480: 0.39367, 485: 0.37832, 490: 0.392506, 495: 0.423255, 500: 0.468951, 505: 0.509823, 510: 0.551923, 515: 0.57673, 520: 0.59894, 525: 0.611155, 530: 0.623829, 535: 0.629598, 540: 0.636475, 545: 0.645361, 550: 0.655589, 555: 0.671682, 560: 0.690295, 565: 0.709359, 570: 0.730587, 575: 0.748998, 580: 0.767832, 585: 0.786295, 590: 0.801043, 595: 0.812518, 600: 0.821303, 605: 0.827334, 610: 0.827494, 615: 0.819016, 616: 0.814072, 617: 0.810179, 618: 0.806287, 619: 0.802012, 620: 0.797737, 625: 0.764787, 630: 0.724964, 635: 0.680899, 640: 0.638133, 645: 0.594845, 650: 0.555125, 655: 0.51894, 660: 0.486181, 665: 0.454614, 670: 0.422297, 675: 0.388355, 680: 0.352992, 685: 0.318193, 690: 0.282697, 695: 0.245701, 700: 0.215906, 705: 0.189853, 710: 0.163229, 715: 0.14476, 720: 0.12737, 725: 0.114158, 730: 0.097674, 735: 0.085444, 740: 0.075708, 745: 0.068751, 750: 0.061453, 755: 0.056451, 760: 0.052251; ColorTemperature: 3783 K; ColorAppearance: 3114 K; sets with these values: 2
